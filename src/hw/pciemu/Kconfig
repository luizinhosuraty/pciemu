## src/hw/pciemu/Kconfig
```kconfig
config PCIEMU
    bool
    default y if TEST_DEVICES
    depends on PCI_EXPRESS && MSI_NONBROKEN
```
